# IAR project vector_rtthread_cm7.ewp, settings and files
configuration sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; DEBUG; CPU_MIMXRT1176DVMAA_cm7; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK; VG_COMMAND_CALL=1; VG_TARGET_FAST_CLEAR=0; SERIAL_PORT_TYPE_UART=1; SDK_OS_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../vglite_support; ../../../../../../components/video; ../../../../../../components/video/display; ../../../../../../components/video/display/rm68191; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../components/video/display/mipi_dsi_cmd; ../../../../../../components/video/display/rm68200; ../../../../../../components/video/display/dc/lcdifv2; ../../../../../../middleware/vglite/inc; ../../../../../../middleware/vglite/font; ../../../../../../middleware/vglite/font/mcufont/decoder; ../../../../../../middleware/vglite/VGLite/rtos; ../../../../../../middleware/vglite/VGLiteKernel; ../../../../../../middleware/vglite/VGLiteKernel/rtos; ../../../../../../components/video/display/dc/elcdif; ../../../../../../components/video/display/hx8394; ../../../../../../components/video/display/fbdev; ../../../../../../devices/MIMXRT1176; ../../../../../../devices/MIMXRT1176/utilities/str; ../../../../../../devices/MIMXRT1176/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1176/xip; ../../../../xip; ../../../../../../devices/MIMXRT1176/drivers/cm7; ../../../../xmcd; ../../../../../../components/video/display/dc; ../../../../../../CMSIS/Core/Include; ../../../../../../rtos/rt-thread; ../../../../../../rtos/rt-thread/include; ../../../../../../rtos/rt-thread/finsh
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: vector_rtthread_cm7.out
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=0; XIP_BOOT_HEADER_XMCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK; VG_COMMAND_CALL=1; VG_TARGET_FAST_CLEAR=0; SERIAL_PORT_TYPE_UART=1; SDK_OS_RTOS
  ICCARM.CCIncludePath2: ..; ../../../vglite_support; ../../../../../../components/video; ../../../../../../components/video/display; ../../../../../../components/video/display/rm68191; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../components/video/display/mipi_dsi_cmd; ../../../../../../components/video/display/rm68200; ../../../../../../components/video/display/dc/lcdifv2; ../../../../../../middleware/vglite/inc; ../../../../../../middleware/vglite/font; ../../../../../../middleware/vglite/font/mcufont/decoder; ../../../../../../middleware/vglite/VGLite/rtos; ../../../../../../middleware/vglite/VGLiteKernel; ../../../../../../middleware/vglite/VGLiteKernel/rtos; ../../../../../../components/video/display/dc/elcdif; ../../../../../../components/video/display/hx8394; ../../../../../../components/video/display/fbdev; ../../../../../../devices/MIMXRT1176; ../../../../../../devices/MIMXRT1176/utilities/str; ../../../../../../devices/MIMXRT1176/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1176/xip; ../../../../xip; ../../../../../../devices/MIMXRT1176/drivers/cm7; ../../../../xmcd; ../../../../../../components/video/display/dc; ../../../../../../CMSIS/Core/Include; ../../../../../../rtos\rt-thread; ../../../../../../rtos\rt-thread\include; ../../../../../../rtos\rt-thread\finsh
  ILINK.IlinkConfigDefines: __use_flash64MB__=1
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK; VG_COMMAND_CALL=1; VG_TARGET_FAST_CLEAR=0; SERIAL_PORT_TYPE_UART=1; SDK_OS_RTOS
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=0; XIP_BOOT_HEADER_XMCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK; VG_COMMAND_CALL=1; VG_TARGET_FAST_CLEAR=0; SERIAL_PORT_TYPE_UART=1; SDK_OS_RTOS
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkConfigDefines: __use_flash64MB__=1
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h dcd.c dcd.h display_support.c display_support.h pin_mux.c pin_mux.h
    ../../../vglite_support/: vglite_support.c vglite_support.h
    ../../../../xmcd/: xmcd.c xmcd.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cachel1_armv7.h cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_port_uart.c fsl_component_serial_port_uart.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_anatop_ai.c fsl_anatop_ai.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_elcdif.c fsl_elcdif.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lcdifv2.c fsl_lcdifv2.h fsl_lpuart.c fsl_lpuart.h fsl_memory.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_pmu.c fsl_pmu.h fsl_soc_mipi_csi2rx.c fsl_soc_mipi_csi2rx.h fsl_soc_src.c fsl_soc_src.h
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group evkbmimxrt1170
    ../: evkbmimxrt1170_connect_cm4_cm7side.jlinkscript
  group rtthread
    ../../../../../../rtos/rt-thread/: board.c
    ../../../../../../rtos/rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../../../../../../rtos/rt-thread/libcpu/arm/cortex-m7/: context_iar.S cpuport.c
  group rtthread/finsh
    ../../../../../../rtos/rt-thread/finsh/: cmd.c finsh_port.c msh.c shell.c
  group source
    ../: rtconfig.h vector_rtthread.c vglite_window.c vglite_window.h
  group startup
    ../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/: fsl_assert.c
    ../../../../../../devices/MIMXRT1176/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
  group vglite
    ../../../../../../middleware/vglite/: ChangeLogKSDK.txt
  group vglite/font
    ../../../../../../middleware/vglite/font/: buf_reader.c buf_reader.h fonts.h rle_font_read.c vft_debug.c vft_debug.h vft_draw.c vft_draw.h vg_lite_text.c
  group vglite/font/mcufont
    ../../../../../../middleware/vglite/font/mcufont/: LICENSE
  group vglite/font/mcufont/decoder
    ../../../../../../middleware/vglite/font/mcufont/decoder/: mcufont.h mf_bwfont.c mf_bwfont.h mf_config.h mf_encoding.c mf_encoding.h mf_font.c mf_font.h mf_justify.c mf_justify.h mf_kerning.c mf_kerning.h mf_rlefont.c mf_rlefont.h mf_scaledfont.c mf_scaledfont.h mf_wordwrap.c mf_wordwrap.h
  group vglite/inc
    ../../../../../../middleware/vglite/inc/: vg_lite.h vg_lite_hal.h vg_lite_text.h
  group vglite/VGLite
    ../../../../../../middleware/vglite/VGLite/: vg_lite.c vg_lite_flat.c vg_lite_flat.h vg_lite_image.c vg_lite_matrix.c vg_lite_path.c
  group vglite/VGLite/rtos
    ../../../../../../middleware/vglite/VGLite/rtos/: vg_lite_os.c vg_lite_os.h
  group vglite/VGLiteKernel
    ../../../../../../middleware/vglite/VGLiteKernel/: vg_lite_hw.h vg_lite_kernel.c vg_lite_kernel.h
  group vglite/VGLiteKernel/rtos
    ../../../../../../middleware/vglite/VGLiteKernel/rtos/: vg_lite_hal.c vg_lite_platform.h
  group video
    ../../../../../../components/video/display/dc/: fsl_dc_fb.h
    ../../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.c fsl_dc_fb_elcdif.h
    ../../../../../../components/video/display/dc/lcdifv2/: fsl_dc_fb_lcdifv2.c fsl_dc_fb_lcdifv2.h
    ../../../../../../components/video/display/: fsl_display.h
    ../../../../../../components/video/display/fbdev/: fsl_fbdev.c fsl_fbdev.h
    ../../../../../../components/video/display/hx8394/: fsl_hx8394.c fsl_hx8394.h
    ../../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.c fsl_mipi_dsi_cmd.h
    ../../../../../../components/video/display/rm68191/: fsl_rm68191.c fsl_rm68191.h
    ../../../../../../components/video/display/rm68200/: fsl_rm68200.c fsl_rm68200.h
    ../../../../../../components/video/: fsl_video_common.c fsl_video_common.h
  group xip
    ../../../../xip/: evkbmimxrt1170_flexspi_nor_config.c evkbmimxrt1170_flexspi_nor_config.h
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
